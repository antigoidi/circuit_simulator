V1 1 0 5
V2 2 0 5
R1 2 3 1e3 G2
MN1 3 1 0 1
