V1 1 0 3
V2 3 0 3
R1 1 2 450 G2
R2 3 4 640 G2
R3 4 5 450 G2
R4 3 6 100 G2
QN1 4 2 0 1
QN2 6 5 7 1
MN1 7 2 0 1
