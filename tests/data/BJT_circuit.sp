V1 1 0 0.4
V2 2 0 0.6
R1 3 0 1e3 G2
QN1 2 1 3 1
