I1 0 1 1
R1 1 0 6 G2
R2 2 0 3 G2
D1 1 2 1
