V1 2 0 1.5
V2 1 0 5
R1 3 0 1e3 G2
MN1 1 2 3 1
