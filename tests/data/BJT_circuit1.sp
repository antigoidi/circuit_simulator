V1 1 0 3
R1 1 2 1e3 G2
R2 1 3 270e3 G2
QN1 2 3 0 1
