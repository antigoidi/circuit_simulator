V1 1 0 2
I1 3 0 1 G2
R1 1 2 1 G2
R2 2 3 1 G2
R3 2 0 1 G2
