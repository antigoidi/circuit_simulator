V1 1 0 2
I1 3 0 1
R1 1 2 1
R2 2 3 1
R3 2 0 1
