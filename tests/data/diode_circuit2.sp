V1 1 0 3
R1 1 2 500 G2
R2 2 0 1e3 G2
R3 3 0 1e3 G2
D1 2 3 1
